# Keil uVision project gsm_stm32f103.uvprojx, settings and files
target gsm_stm32f103 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: gsm_stm32f103 +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --C99
  c include: ../Inc;   ../Drivers/STM32F1xx_HAL_Driver/Inc;   ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;   ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;   ../Drivers/CMSIS/Include;   ..\Hardware\SSD1306;   ..\Hardware\delay;   ..\Hardware\GSM_LIB\GENERAL;   ..\Hardware\GSM_LIB\USART;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Hardware/delay/: delay.c
    ../Src/: main.c event_system.c event_functions.c init_mc.c util.c interrupt.c
  group SSD1306
    ../Hardware/SSD1306/: SSD1306.c Fonts.c
  group GSM
    ../Hardware/GSM_LIB/GENERAL/: gsm_common.c gsm.c
    ../Hardware/GSM_LIB/USART/: gsm_usart.c
software components: CMSIS:CORE 5.0.1
